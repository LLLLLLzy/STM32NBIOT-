# Keil uVision project NBIOT.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NBIOT +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\APP;..\STM32F10x_FWLib\inc;..\CM3;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\USART2;..\SIM800C;..\HARDWARE\USART3;..\LCD5110;..\HARDWARE\NBIOT;..\HARDWARE\adc;..\HARDWARE\HEXSTR;..\NBIOT;..\HARDWARE\dht11
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./: system_stm32f10x.c main.c stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
    ../LCD5110/: LCD5110.c
    ./: beep.c
    ../HARDWARE/adc/: ADCx.c
    ../HARDWARE/HEXSTR/: HEXSTR.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/HTTP/: HTTP_Demo.c
    ../HARDWARE/dht11/: dht11.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CM3
    ../CM3/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_adc.c
  group NBIOT
    ../NBIOT/: nbiot.c
software components: CMSIS:CORE 4.1.0
